# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ../网上资料/mpu6050_data_processing-master/: delay.c filter.c iic.c main.c mpu6050.c uart.c delay.h filter.h iic.h mpu6050.h uart.h
