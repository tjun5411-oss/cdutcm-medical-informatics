# Keil uVision project SYN6288.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: SYN6288 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\IIC_OLED
  group Source Group 1
    ./: main.c
